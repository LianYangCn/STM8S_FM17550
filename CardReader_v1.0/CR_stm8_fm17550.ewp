# IAR project CR_stm8_fm17550.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader\user\FM17550\Driver; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader\user\FM17550\Middle; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader\Libraries\STM8S_StdPeriph_Driver\inc; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader\Libraries\STM8S_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: CR_stm8_fm17550.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\Libraries\STM8S_StdPeriph_Driver\inc; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\user; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\user\FM17550\Driver; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\user\FM17550\Middle; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\user\Mcu_Init; D:\work_lj\ProjectBuilder\STM8S_FM17550\CardReader_v1.0\user\FM17550
  OBJCOPY.OOCOutputFile: CR_stm8_fm17550.hex
  ILINK.IlinkOutputFile: CR_stm8_fm17550.out
  group (top)
    user/: Include.h
    ./: main.c stm8s_it.c stm8s_it.h
  group Ecal
    user/FM17550/: UartCmn.c UartCmn.h
  group Ecal/FM17550/Driver/fm17550
    user/FM17550/Driver/: fm175xx.c fm175xx.h fm175xx_cfg.c fm175xx_cfg.h
  group Ecal/FM17550/Middle
    user/FM17550/Middle/: 15693.h CardRd.c CardRd.h CardRd_cfg.c CardRd_cfg.h CardTypeDefine.h cpu_card.h des.h mifare_card.c mifare_card.h psam.h StatusCode.h stdint.h type_a.c type_a.h type_b.c type_b.h ultralight.h Utility.c Utility.h
  group Ecal/MemIf
    user/FM17550/: MemIf.c MemIf.h MemIf_cfg.c MemIf_cfg.h
  group Ecal/TX522B
    user/FM17550/: Tx522b.c Tx522b.h Tx522b_cfg.c Tx522b_cfg.h
  group Mcal/Libraries/inc
    Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group Mcal/Libraries/Mcu_Init
    user/Mcu_Init/: Mcu_Init.c Mcu_Init.h
  group Mcal/Libraries/src
    Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
